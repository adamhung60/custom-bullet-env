Commit message: f

File: bullet_env/bullet_env/envs/robot/robot.urdf (robot description, URDF)
Before this commit: robot onshape, 4 links, 3 joints
Joints:
- joint w1: limit effort=500 velocity=20 -> effort=1000 velocity=1000
- joint w2: limit effort=500 velocity=20 -> effort=1000 velocity=1000
